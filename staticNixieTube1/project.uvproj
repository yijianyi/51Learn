# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Function\delay;..\Function\Nixie
  group Source Group 1
    ./: main.c
    ../Function/Nixie/: Nixie.c
    ../Function/delay/: Delay.c
