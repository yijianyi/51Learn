# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: E:\51\C51\INC\Atmel
  group Source Group 1
    ./: main.c Timer0.c LCD1602.c LCD1602.h Timer0.h
